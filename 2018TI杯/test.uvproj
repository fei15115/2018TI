# Keil uVision project test.uvproj, settings and files
target 电流检测 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\应用
  group 应用
    ./: main.c LCD_ALI.c
    ./应用/: FFT.C HD7279.C STC_HW.C
